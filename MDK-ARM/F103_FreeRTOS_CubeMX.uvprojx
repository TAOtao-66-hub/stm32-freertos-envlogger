# Keil uVision project F103_FreeRTOS_CubeMX.uvprojx, settings and files
target F103_FreeRTOS_CubeMX (5060960::V5.06 update 7 (build 960)::.\ARMCC\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: F103_FreeRTOS_CubeMX +hex
  BeforeMake: cmd.exe /c "..\Tools\check_project.cmd"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: serial_command.c serial_report.c env_alarm.c settings_store.c env_monitor.c main.c gpio.c freertos.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c history_store.c history_buffer.c history_transfer.c project_commands.c rtos_diagnostics.c storage_codec.c storage_service.c time_calendar.c
  group Application .h
    ../Core/Inc/: serial_command.h serial_report.h project_config.h env_alarm.h settings_store.h gpio.h env_monitor.h FreeRTOSConfig.h main.h stm32f1xx_hal_conf.h stm32f1xx_it.h history_store.h history_buffer.h history_transfer.h project_commands.h rtos_diagnostics.h storage_codec.h storage_service.h
  group User Drivers .c
    ../Core/Src/: serial_port.c button.c buzzer.c led.c board_timing.c soft_i2c.c dht11_decoder.c dht11.c oled.c potentiometer.c time_service.c w25qxx.c
  group User Drivers .h
    ../Core/Inc/: serial_port.h button.h buzzer.h led.h board_timing.h dht11.h dht11_decoder.h oled.h soft_i2c.h potentiometer.h time_service.h w25qxx.h
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_uart.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c
  group HAL .h
    ../Drivers/STM32F1xx_HAL_Driver/Inc/: stm32f1xx_hal_uart.h stm32f1xx_hal.h stm32f1xx_hal_cortex.h stm32f1xx_hal_def.h stm32f1xx_hal_dma.h stm32f1xx_hal_dma_ex.h stm32f1xx_hal_exti.h stm32f1xx_hal_flash.h stm32f1xx_hal_flash_ex.h stm32f1xx_hal_gpio.h stm32f1xx_hal_gpio_ex.h stm32f1xx_hal_pwr.h stm32f1xx_hal_rcc.h stm32f1xx_hal_rcc_ex.h stm32f1xx_hal_tim.h stm32f1xx_hal_tim_ex.h stm32f1xx_ll_bus.h stm32f1xx_ll_cortex.h stm32f1xx_ll_dma.h stm32f1xx_ll_exti.h stm32f1xx_ll_gpio.h stm32f1xx_ll_pwr.h stm32f1xx_ll_rcc.h stm32f1xx_ll_system.h stm32f1xx_ll_utils.h stm32f1xx_hal_spi.h stm32f1xx_hal_adc.h stm32f1xx_hal_adc_ex.h stm32f1xx_hal_rtc.h stm32f1xx_hal_rtc_ex.h
    ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group CMSIS .h
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Include/: stm32f103xb.h stm32f1xx.h system_stm32f1xx.h
    ../Drivers/CMSIS/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h tz_context.h
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group FreeRTOS .h
    ../Middlewares/Third_Party/FreeRTOS/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: portmacro.h
software components: CMSIS:CORE 4.3.0
